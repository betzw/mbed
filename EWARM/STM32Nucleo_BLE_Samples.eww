<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32Nucleo_BLE_Samples.ewp</path>
  </project>
  <batchBuild/>
</workspace>