# IAR project STM32Nucleo_BLE_Samples.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TARGET_NUCLEO_F401RE; TARGET_M4; TARGET_CORTEX_M; TARGET_STM; TARGET_STM32F4; TARGET_STM32F401RE; TOOLCHAIN_IAR; __CORTEX_M4; ARM_MATH_CM4; __FPU_PRESENT=1; MBED_BUILD_TIMESTAMP=1433856215.33; __MBED__=1; TARGET_FF_ARDUINO; TARGET_FF_MORPHO
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.CCIncludePath2: .; ../Samples; ../../mbed; ../../mbed/TARGET_NUCLEO_F401RE; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR; ../../mbed/TARGET_NUCLEO_F401RE/TARGET_STM; ../../mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4; ../../mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE; ../../BLE_API; ../../BLE_API/common; ../../BLE_API/services; ../../BLE_API/public; ../../BLE_BlueNRG; ../../BLE_BlueNRG/utils; ../../BLE_BlueNRG/utils/src; ../../BLE_BlueNRG/utils/inc; ../../BLE_BlueNRG/BlueNRG_HCI; ../../BLE_BlueNRG/BlueNRG_HCI/utils; ../../BLE_BlueNRG/BlueNRG_HCI/hci; ../../BLE_BlueNRG/BlueNRG_HCI/hci/controller; ../../BLE_BlueNRG/BlueNRG_HCI/includes; ../../BLE_BlueNRG/platform; ../../BLE_BlueNRG/platform/X-NUCLEO-IDB04A1; ../../BLE_BlueNRG/platform/src; ../../BLE_BlueNRG/platform/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32Nucleo_BLE_Samples.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f401xe.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization
  ILINK.IlinkAdditionalLibs: ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/mbed.a; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dma.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_spdifrx.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_pcd.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_hash.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_cryp.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_usart.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_nor.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_uart.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_adc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_rcc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_flash.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dac.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_rtc_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_i2c.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/mbed_overrides.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_crc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_cec.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_ll_sdmmc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/cmain.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_msp_template.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_ll_fmc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_ll_usb.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_i2s_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/startup_stm32f401xe.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_rtc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_sd.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_qspi.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_sram.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_fmpi2c.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_iwdg.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/board.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_pwr_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_tim.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_eth.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_flash_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_smartcard.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dcmi.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_sai_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/system_stm32f4xx.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_gpio.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dcmi_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_tim_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_sdram.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dma_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/cmsis_nvic.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dac_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_hcd.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_pccard.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/hal_tick.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_hash_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_ltdc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_dma2d.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_fmpi2c_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_rcc_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/retarget.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_spi.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_cortex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_irda.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_wwdg.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_sai.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_pcd_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_pwr.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_cryp_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_rng.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_nand.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_ll_fsmc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_flash_ramfunc.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_adc_ex.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_i2s.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_can.o; ../../mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_IAR/stm32f4xx_hal_i2c_ex.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ../: main.cpp
  group BLE_API/common
    ../../BLE_API/common/: BLEDevice.cpp
  group BLE_API/services
    ../../BLE_API/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
  group BLE_BlueNRG
    ../../BLE_BlueNRG/: BlueNRGDevice.cpp BlueNRGGap.cpp BlueNRGGattServer.cpp
  group BLE_BlueNRG/BlueNRG_HCI/hci
    ../../BLE_BlueNRG/BlueNRG_HCI/hci/: hci.c hci_dma_lp.c
  group BLE_BlueNRG/BlueNRG_HCI/hci/controller
    ../../BLE_BlueNRG/BlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils.c
  group BLE_BlueNRG/BlueNRG_HCI/utils
    ../../BLE_BlueNRG/BlueNRG_HCI/utils/: gp_timer.c list.c osal.c
  group BLE_BlueNRG/platform/src
    ../../BLE_BlueNRG/platform/src/: btle.cpp clock.c
  group BLE_BlueNRG/platform/X-NUCLEO-IDB04A1
    ../../BLE_BlueNRG/platform/X-NUCLEO-IDB04A1/: stm32_bluenrg_ble.c stm32_bluenrg_ble_dma_lp.c
  group BLE_BlueNRG/utils/src
    ../../BLE_BlueNRG/utils/src/: Payload.cpp Utils.cpp
  group Samples
    ../Samples/: HRMSample.cpp SensorDemo.cpp SensorService.cpp
